# Keil uVision project freertos_hello_cm33_core0.uvprojx, settings and files
target freertos_hello_cm33_core0 debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: freertos_hello_cm33_core0.out
  AfterMake: fromelf.exe --output "$Lfreertos_hello.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXN947VDF_cm33_core0, SDK_OS_FREE_RTOS
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MCXN947/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MCXN947;../../../../../../devices/MCXN947/periph;../../../../../../devices/MCXN947/utilities/debug_console_lite;../../../../../../devices/MCXN947/utilities/str;../../../../../../components/uart;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../rtos/freertos/freertos-kernel/template
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, MCUXPRESSO_SDK, CPU_MCXN947VDF_cm33_core0
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: freertos_hello.c FreeRTOSConfig_Gen.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_COMMON.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group device/periph
    ../../../../../../devices/MCXN947/periph/: PERI_ADC.h PERI_AHBSC.h PERI_BSP32.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAN.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DIGTMP.h PERI_DM.h PERI_DMA.h PERI_EIM.h PERI_EMVSIM.h PERI_ENET.h PERI_ERM.h PERI_EVTG.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FMU.h PERI_FMUTEST.h PERI_FREQME.h PERI_GDET.h PERI_GPIO.h PERI_HPDAC.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_INTM.h PERI_ITRC.h PERI_LPCMP.h PERI_LPDAC.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MAILBOX.h PERI_MRT.h PERI_NPX.h PERI_OPAMP.h PERI_OSTIMER.h PERI_OTPC.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PLU.h PERI_PORT.h PERI_POWERQUAD.h PERI_PUF.h PERI_PWM.h PERI_QDC.h PERI_RTC.h PERI_S50.h PERI_SCG.h PERI_SCT.h PERI_SEMA42.h PERI_SINC.h PERI_SMARTDMA.h PERI_SPC.h PERI_SYSCON.h PERI_SYSPM.h PERI_TRDC.h PERI_TSI.h PERI_USB.h PERI_USBDCD.h PERI_USBHS.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_VBAT.h PERI_VREF.h PERI_WUU.h PERI_WWDT.h
  group startup/arm
    ../../../../../../devices/MCXN947/arm/: startup_MCXN947_cm33_core0.S
  group utilities
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MCXN947/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
target freertos_hello_cm33_core0 release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: freertos_hello_cm33_core0.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXN947VDF_cm33_core0, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, MCUXPRESSO_SDK, CPU_MCXN947VDF_cm33_core0
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: as above
