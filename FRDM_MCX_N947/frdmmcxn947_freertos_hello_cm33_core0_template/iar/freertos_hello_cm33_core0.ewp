# IAR project freertos_hello_cm33_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXN947VDF_cm33_core0; SDK_OS_FREE_RTOS
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MCXN947/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MCXN947; ../../../../../../devices/MCXN947/periph; ../../../../../../devices/MCXN947/utilities/debug_console_lite; ../../../../../../devices/MCXN947/utilities/str; ../../../../../../components/uart; ../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../rtos/freertos/freertos-kernel/template
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MCXN947VDF_cm33_core0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_hello.bin
  ILINK.IlinkOutputFile: freertos_hello_cm33_core0.out
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXN947VDF_cm33_core0; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group source
    ../: freertos_hello.c FreeRTOSConfig_Gen.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpflexcomm.h fsl_lpflexcomm.c fsl_lpuart.h fsl_lpuart.c fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_COMMON.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group device/periph
    ../../../../../../devices/MCXN947/periph/: PERI_ADC.h PERI_AHBSC.h PERI_BSP32.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CAN.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DIGTMP.h PERI_DM.h PERI_DMA.h PERI_EIM.h PERI_EMVSIM.h PERI_ENET.h PERI_ERM.h PERI_EVTG.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FMU.h PERI_FMUTEST.h PERI_FREQME.h PERI_GDET.h PERI_GPIO.h PERI_HPDAC.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_INTM.h PERI_ITRC.h PERI_LPCMP.h PERI_LPDAC.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_LP_FLEXCOMM.h PERI_MAILBOX.h PERI_MRT.h PERI_NPX.h PERI_OPAMP.h PERI_OSTIMER.h PERI_OTPC.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PLU.h PERI_PORT.h PERI_POWERQUAD.h PERI_PUF.h PERI_PWM.h PERI_QDC.h PERI_RTC.h PERI_S50.h PERI_SCG.h PERI_SCT.h PERI_SEMA42.h PERI_SINC.h PERI_SMARTDMA.h PERI_SPC.h PERI_SYSCON.h PERI_SYSPM.h PERI_TRDC.h PERI_TSI.h PERI_USB.h PERI_USBDCD.h PERI_USBHS.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_VBAT.h PERI_VREF.h PERI_WUU.h PERI_WWDT.h
  group startup/iar
    ../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group utilities
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md example_board_readme.md examples_shared_readme.md
